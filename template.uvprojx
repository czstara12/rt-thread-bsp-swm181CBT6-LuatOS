# Keil uVision project template.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM181xB Synwit
  pack: Synwit.SWM32_DFP.1.20.3
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1E000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\drivers\linker_scripts\link.sct
